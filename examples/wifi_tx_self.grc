<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wi_tx_self</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>out_buf_size</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>encoding</value></param>
<param><key>label</key><value>Encoding</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1,2,3,4,5,6,7]</value></param>
<param><key>labels</key><value>["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>ieee802_11_ofdm_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_mac_0</value></param>
<param><key>src_mac</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
<param><key>dst_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 255]</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>period</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>100</value></param>
<param><key>min</key><value>1</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1500</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>label</key><value>LO Offset</value></param>
<param><key>value</key><value>11e6</value></param>
<param><key>choices</key><value>[0, 6e6, 11e6]</value></param>
<param><key>labels</key><value>['0 MHz', '6 MHz', '11 MHz']</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0</value></param>
<param><key>chan_est</key><value>0</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>sensitivity</key><value>0.56</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>mult</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>.24</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>20e6</value></param>
<param><key>choices</key><value>[10e6, 20e6]</value></param>
<param><key>labels</key><value>["10 Mhz", "20 Mhz"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>value</key><value>2.412e9</value></param>
<param><key>choices</key><value>[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5260000000.0, 5280000000.0, 5300000000.0, 5320000000.0, 5500000000.0, 5520000000.0, 5540000000.0, 5560000000.0, 5580000000.0, 5600000000.0, 5620000000.0, 5640000000.0, 5660000000.0, 5680000000.0, 5700000000.0, 5745000000.0, 5765000000.0, 5785000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]</value></param>
<param><key>labels</key><value>['  1 | 2412.0 | 11g', '  2 | 2417.0 | 11g', '  3 | 2422.0 | 11g', '  4 | 2427.0 | 11g', '  5 | 2432.0 | 11g', '  6 | 2437.0 | 11g', '  7 | 2442.0 | 11g', '  8 | 2447.0 | 11g', '  9 | 2452.0 | 11g', ' 10 | 2457.0 | 11g', ' 11 | 2462.0 | 11g', ' 12 | 2467.0 | 11g', ' 13 | 2472.0 | 11g', ' 14 | 2484.0 | 11g', ' 34 | 5170.0 | 11a', ' 36 | 5180.0 | 11a', ' 38 | 5190.0 | 11a', ' 40 | 5200.0 | 11a', ' 42 | 5210.0 | 11a', ' 44 | 5220.0 | 11a', ' 46 | 5230.0 | 11a', ' 48 | 5240.0 | 11a', ' 52 | 5260.0 | 11a', ' 56 | 5280.0 | 11a', ' 58 | 5300.0 | 11a', ' 60 | 5320.0 | 11a', '100 | 5500.0 | 11a', '104 | 5520.0 | 11a', '108 | 5540.0 | 11a', '112 | 5560.0 | 11a', '116 | 5580.0 | 11a', '120 | 5600.0 | 11a', '124 | 5620.0 | 11a', '128 | 5640.0 | 11a', '132 | 5660.0 | 11a', '136 | 5680.0 | 11a', '140 | 5700.0 | 11a', '149 | 5745.0 | 11a', '153 | 5765.0 | 11a', '157 | 5785.0 | 11a', '161 | 5805.0 | 11a', '165 | 5825.0 | 11a', '172 | 5860.0 | 11p', '174 | 5870.0 | 11p', '176 | 5880.0 | 11p', '178 | 5890.0 | 11p', '180 | 5900.0 | 11p', '182 | 5910.0 | 11p', '184 | 5920.0 | 11p']</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>ieee802_11_ofdm_parse_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_parse_mac_0</value></param>
<param><key>log</key><value>True</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>delay_sec</key><value>0.01</value></param>
<param><key>pad_front</key><value>100</value></param>
<param><key>pad_tail</key><value>1000</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant0</key><value></value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>ant0</key><value></value></param>
<param><key>minoutbuf</key><value>1048576</value></param>
<param><key>maxoutbuf</key><value>1048576</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>mult</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Costellation</value></param>
<param><key>samp_rate</key><value>5000</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
<param><key>host</key><value></value></param>
<param><key>port</key><value>52001</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("duanzhengbing")</value></param>
<param><key>period</key><value>period</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
<param><key>host</key><value>192.168.191.2</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
</block>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>ieee802_11_ofdm_mac_0</sink_block_id><source_key>mac_out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_mac_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>phy out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>foo_packet_pad2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>ieee802_11_ofdm_mac_0</sink_block_id><source_key>strobe</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>ieee802_11_ofdm_parse_mac_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>ieee802_11_ofdm_mac_0</sink_block_id><source_key>pdus</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_parse_mac_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>fer</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
